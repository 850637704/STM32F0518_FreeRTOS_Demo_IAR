# IAR project STM32F051_FreeRtos_Demo_IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051x8 ST STM32F051x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STM320518_EVAL; STM32F0XX; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\FWLIB\STM32F0xx_StdPeriph_Driver\inc; ..\FWLIB\CMSIS\Include; ..\FWLIB\CMSIS\Device\ST\STM32F0xx\Include; ..\FreeRTOS\include; ..\FreeRTOS\portable\IAR\ARM_CM0; ..\BSP; ..\BSP\Common\include; ..\USER
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\USER; ..\BSP
  ILINK.IlinkOutputFile: STM32F051_FreeRtos_Demo_IAR.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group BSP
    ../BSP/: bsp.c clock.c led.c tim3.c usart1.c
  group FreeRtos
    ../FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_2.c
    ../FreeRTOS/portable/IAR/ARM_CM0/: port.c portasm.s
  group FWLIB
    ../FWLIB/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f0xx.s
    ../FWLIB/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_tim.c stm32f0xx_usart.c
    ../FWLIB/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group USER
    ../USER/: app_cfg.h FreeRTOSConfig.h includes.h main.c stm32f0xx_conf.h
